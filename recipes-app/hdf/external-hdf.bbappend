FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

HDF_BASE = "file://"
HDF_PATH = "axi_lamports_bakery_algo.xsa"

