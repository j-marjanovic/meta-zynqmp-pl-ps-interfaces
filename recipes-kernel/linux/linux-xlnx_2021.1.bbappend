FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " \
    file://0000-fpga-mgr-debugfs.cfg \
"

